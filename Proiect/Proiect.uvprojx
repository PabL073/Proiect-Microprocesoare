# Keil uVision project Proiect.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.1
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Proiect
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./: main.c Gpio.h Gpio.c Pit.c Pit.h Adc.c Adc.h Uart.c Uart.h Pwm.h Pwm.c ClockSettings.c ClockSettings.h tsi.c tsi.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.5.0
